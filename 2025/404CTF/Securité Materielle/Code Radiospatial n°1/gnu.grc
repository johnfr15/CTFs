options:
  parameters:
    generate_options: qt_gui
    id: gnu
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: cutoff_freq
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '10000000'
    value: '10000'
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '100'
  states: {}
- name: dev_hi
  id: variable
  parameters:
    value: '3125'
  states: {}
- name: dev_hi_0
  id: variable
  parameters:
    value: '3125'
  states: {}
- name: fsk_deviation_hz
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '10000000'
    value: '4500'
  states: {}
- name: samp_per_sym
  id: variable
  parameters:
    value: 48000 / 512
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '4915200'
  states: {}
- name: transition_w
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '10000000'
    value: '2000'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: 'samp_rate / decimation  / (2*math.pi*fsk_deviation_hz) '
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/john/Desktop/CTFs/2025/404CTF/Securité Materielle/Code Radiospatial n°1/out.txt
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/john/Desktop/CTFs/2025/404CTF/Securité Materielle/Code Radiospatial n°1/chall.iq
    repeat: 'True'
    type: complex
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.175'
    gain_omega: 0.25*0.175*0.175
    mu: '0.5'
    omega: samp_per_sym*(1+0.0)
    omega_relative_limit: '0.005'
    type: float
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '10000'
    decim: '100'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate / decimation
    fc: '0'
    fftsize: '1024'
    name: '"After"'
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"Before low pass filter"'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '49152'
    interp: '48000'
    type: fff
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', rational_resampler_xxx_0, '0']
- [blocks_file_source_0, '0', low_pass_filter_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_file_sink_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [low_pass_filter_0, '0', analog_quadrature_demod_cf_0, '0']
- [low_pass_filter_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [rational_resampler_xxx_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
